## boards/shields/nice_shield/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_SHIELD_BASE
    def_bool $(shields_list_contains,nice_shield_base)
```
